# Keil uVision project Task2_PWM_Breathing.uvprojx, settings and files
target Task2_PWM_Breathing (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Task2_PWM_Breathing +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .;.\CMSIS
  asm include: .;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group User
    ./: main.c
  group StdPeriph_Driver
    ./: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c misc.c
